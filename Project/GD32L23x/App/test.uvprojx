# Keil uVision project test.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32L233RC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c include: .\app;..\..\..\DAL;..\..\..\DML;..\..\..\Driver\GD32L23X\CMSIS\GD32L23x\Include;..\..\..\Driver\GD32L23X\driver;..\..\..\Driver\GD32L23X\GD32L23x_standard_peripheral\Include;..\..\..\Component\RTT;..\..\..\Utilities\hash\string_hash;..\..\..\Utilities\list;..\..\..\Driver\ARM_CORE;.\sys;..\..\..\Utilities\stimer
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ./app/: app_init.c app_led.c main.c
  group dal
    ../../../DAL/: dal_char_dev.c
  group dml
    ../../../DML/: dml_char_device.c dml_init.c
  group driver
    ../../../Driver/GD32L23X/CMSIS/GD32L23x/Source/: system_gd32l23x.c
    ../../../Driver/GD32L23X/CMSIS/GD32L23x/Source/ARM/: startup_gd32l233xx.s
    ../../../Driver/GD32L23X/GD32L23x_standard_peripheral/Source/: gd32l23x_adc.c gd32l23x_cau.c gd32l23x_cau_aes.c gd32l23x_cau_des.c gd32l23x_cau_tdes.c gd32l23x_cmp.c gd32l23x_crc.c gd32l23x_ctc.c gd32l23x_dac.c gd32l23x_dbg.c gd32l23x_dma.c gd32l23x_exti.c gd32l23x_fmc.c gd32l23x_fwdgt.c gd32l23x_gpio.c gd32l23x_i2c.c gd32l23x_lptimer.c gd32l23x_lpuart.c gd32l23x_misc.c gd32l23x_pmu.c gd32l23x_rcu.c gd32l23x_rtc.c gd32l23x_slcd.c gd32l23x_spi.c gd32l23x_syscfg.c gd32l23x_timer.c gd32l23x_trng.c gd32l23x_usart.c gd32l23x_vref.c gd32l23x_wwdgt.c
    ../../../Driver/GD32L23X/driver/: driver_led_green.c driver_stimer.c
  group components
    ../../../Component/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group utilities
    ../../../Utilities/hash/string_hash/: string_hash.c
    ../../../Utilities/list/: list.c
    ../../../Utilities/stimer/: stimer.c
  group sys
    ./sys/: gd32l23x_it.c systick.c
